Commit message: Changed the mass for the mug from 1 to 0.1 (kg, presumably)

File: models/mug.urdf (robot description, URDF)
Before this commit: robot mug, 1 links, 0 joints
Links:
- link body: mass 1 -> 0.1
